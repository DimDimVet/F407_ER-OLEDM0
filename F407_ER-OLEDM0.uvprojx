# Keil uVision project F407_ER-OLEDM0.uvprojx, settings and files
target F407_ER-OLEDM0 (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_ER-OLEDM0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: F:\F407_ER-OLEDM0;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c
  group inc
    ./inc/: app.h init_LED.h delay.h init_I2C.h init_USART.h ssd1306.h fonts.h
  group init
    ./init/: init_LED.c delay.c init_I2C.c init_USART.c ssd1306.c fonts.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
